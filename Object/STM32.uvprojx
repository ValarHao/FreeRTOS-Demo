# Keil uVision project STM32.uvprojx, settings and files
target Demo (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CM3;..\Object;..\STM32F10x_FWLib\inc;..\FreeRTOS\config;..\FreeRTOS\include;..\FreeRTOS\portable\ARM_CM3;..\CODE\SYS;..\CODE\GLOBAL;..\CODE\LED
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c
  group CM3
    ../CM3/: core_cm3.c startup_stm32f10x_md.s
  group CODE
    ../CODE/SYS/: sys.c
    ../CODE/GLOBAL/: global.c
    ../CODE/LED/: led.c
  group Object
    ./: main.c system_stm32f10x.c
  group FreeRTOS
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/ARM_CM3/: port.c
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
